# Keil uVision project Blinky.uvprojx, settings and files
target Simulation (6180000::V6.18::ARMCLANG)
  device: ARMCM4 ARM
  pack: ARM.CMSIS.5.9.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M4") CLOCK(12000000) ESEL ELITTLE
  output: Blinky
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0xff000
  memory RVCT9: RAM 0x20000000 size 0xfffff
  memory RVCT10: RAM 0x40000000 size 0xfffff
  scatter file: .\RTE\Device\ARMCM4\ARMCM4_ac6.sct
  group Source Files
    ./: main.c asm.s tables.c skinny128.c skinny128.h tk_schedule.c tk_schedule.h
  group Documentation
    ./: Abstract.txt
software components: CMSIS:CORE 5.5.0, CMSIS:RTOS2:Keil RTX5 5.5.3, Device:Startup 2.0.3, Compiler:Event Recorder 1.4.0, Compiler:I/O:STDOUT 1.2.0
